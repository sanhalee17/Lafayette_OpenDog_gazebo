Commit message: Update openDog_full_whip.urdf

File: urdf/openDog_full_whip.urdf (robot description, URDF)
Before this commit: robot opendog, 18 links, 17 joints
Links:
- link foot_1: mass 0.0 -> 0.01
- link foot_2: mass 0.0 -> 0.01
- link foot_3: mass 0.0 -> 0.01
- link foot_4: mass 0.0 -> 0.01
